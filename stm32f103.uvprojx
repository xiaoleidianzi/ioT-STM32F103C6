# Keil uVision project stm32f103.uvprojx, settings and files
target STM32F103 (ARM-ADS)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x8000) IRAM(0x20000000,0x2800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103 +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F10X_LD, USE_STDPERIPH_DRIVER
  c include: .\core;.\fwlib\inc;.\hardware\inc;.\user;.\NET\onenet\inc;.\NET\MQTT;.\NET\device\inc;.\
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group core
    ./core/: core_cm3.c stm32f10x_it.c system_stm32f10x.c
    ./core/startup/arm/: startup_stm32f10x_hd.s
  group fwlib
    ./fwlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_adc.c stm32f10x_dma.c
  group hardware
    ./hardware/src/: beep.c delay.c key.c led.c usart.c
  group user
    ./user/: main.c
    ./: Config.h
  group OneNET
    ./NET/onenet/src/: onenet.c hmac_sha1.c base64.c
  group net_protocol
    ./NET/MQTT/: MqttKit.c
  group net_device
    ./NET/device/src/: esp8266.c
  group ::Device
    RTE/Device/STM32F103C6/: RTE_Device.h startup_stm32f10x_ld.s system_stm32f10x.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
